# Keil uVision project master.uvprojx, settings and files
target STM32 (ARM-ADS)
  device: STM32F373VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(72000000) ELITTLE
  output: master +hex
  c flags: Optim=4
  c define: HSE_VALUE=8000000, USE_STDPERIPH_DRIVER, STM32F37X
  c include: ..\..\master;..\SPI_Lib;..\STM32F37x_DSP_StdPeriph_Lib_V1.0.0\Libraries\CMSIS\Device\ST\STM32F37x\Include;..\STM32F37x_DSP_StdPeriph_Lib_V1.0.0\Libraries\STM32F37x_StdPeriph_Driver\inc;..\STM32_Cryptographic_library_package_V2.0.6\Libraries\STM32_Cryptographic_Library\inc;..\STM32_USB-Host-Device_Lib_V2.1.0\Libraries\STM32_USB_OTG_Driver\inc;..\STM32_USB-Host-Device_Lib_V2.1.0\Libraries\STM32_USB_Device_Library\Core\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main Code
    ../: main.c init.c pre_config.c flash_structures.c topology.c
  group CMSIS
    ../: system_stm32f37x.c
  group Core
    ../: startup_stm32f37x.s
  group SPL
    ../: stm32f37x_conf.h
    ../STM32F37x_DSP_StdPeriph_Lib_V1.0.0/Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_crc.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_misc.c stm32f37x_rtc.c stm32f37x_rcc.c stm32f37x_sdadc.c stm32f37x_spi.c stm32f37x_exti.c stm32f37x_tim.c stm32f37x_pwr.c stm32f37x_syscfg.c
  group Peripherals
    ../: in_logic.c out_logic.c dac.c adc.c
  group MRF49XA
    ../SPI_Lib/: spi_low.c mrf49xa.c
    ../: rft_handlers.c crypto_functions.c
  group CryptoLibrary
    ../STM32_Cryptographic_library_package_V2.0.6/Libraries/STM32_Cryptographic_Library/binary/MK-ARM/: M4_CryptoFW_2_0_6.lib
  group USB
    ../STM32_USB-Host-Device_Lib_V2.1.0/Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../STM32_USB-Host-Device_Lib_V2.1.0/Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../: usb_bsp.c usbd_desc.c usbd_hid_core.c usbd_usr.c
